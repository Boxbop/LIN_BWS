# IAR project Lin_Master_Example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: can128 AT90CAN128
  ICCAVR.CCDiagSuppress: Pa082
  ICCAVR.newCCIncludePaths: ..\; ..\..\; ..\..\..\; ..\; 
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkcan128s.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.GenDeviceSelectMenu: 0 -v0, Max 256 byte data, 8 Kbyte code
  ICCAVR.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../LIB_MCU/LIN_UART/: lin_drv_usart.c lin_lib.c master_lin.c
    ./: lin_master_example_main.c timer1ovf_isr.c timer2ovf_isr.c
    ../LIB_MCU/TIMER/: timer2_lib.c
