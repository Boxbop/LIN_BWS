# IAR project Backup of Lin_Master_Example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDiagSuppress: Pa082
  ICCAVR.newCCIncludePaths: ..\; ..\..\; ..\..\..\; ..\; 
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkcan128s.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../LIB_MCU/LIN_UART/: lin_drv_usart.c lin_lib.c master_lin.c
    ./: lin_master_example_main.c timer1ovf_isr.c timer2ovf_isr.c
    ../LIB_MCU/TIMER/: timer2_lib.c
