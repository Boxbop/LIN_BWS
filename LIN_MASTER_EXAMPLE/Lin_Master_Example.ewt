<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>AVR</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>AVR</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <file>
    <name>$PROJ_DIR$\..\LIB_MCU\LIN_UART\lin_drv_usart.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\LIB_MCU\LIN_UART\lin_lib.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\lin_master_example_main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\LIB_MCU\LIN_UART\master_lin.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\timer1ovf_isr.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\LIB_MCU\TIMER\timer2_lib.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\timer2ovf_isr.c</name>
  </file>
</project>


